# KOMPAS-3D part (ZARDP 125.016.21.P.m3d)

Model tree:
1. Операция без истории:1
